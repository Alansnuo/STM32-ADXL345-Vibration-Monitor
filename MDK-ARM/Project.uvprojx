# Keil uVision project Project.uvprojx, settings and files
target Project (6240000::V6.24::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.3.2.0
  cpu: IRAM(0x20000000-0x200BFFFF) IROM(0x08000000-0x81FFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ DSP
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32U575xx
  c include: ../Core/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc;../Drivers/STM32U5xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32U5xx/Include;../Drivers/CMSIS/Include;../LVGL;../LVGL/src;../LVGL/porting;../LVGL_myGUI;../BSP/LCD;../BSP/FT6336U;../App;../App/lvgl;../App/lcd;../freertos/inc;../freertos/port;../freertos/src
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  group Application/MDK-ARM
    ./: startup_stm32u575xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma2d.c gpdma.c i2c.c spi.c tim.c usart.c stm32u5xx_it.c stm32u5xx_hal_msp.c stm32u5xx_hal_timebase_tim.c
  group App
    ../App/: app_config.h app_freertos.c app_freertos.h
    ../App/lvgl/: task_lvgl.c task_lvgl.h
    ../App/lcd/: task_lcd.c task_lcd.h
  group LVGL_myGUI
    ../LVGL_myGUI/: ui.c ui.h
  group BSP
    ../BSP/LCD/: st7789.c st7789.h
    ../BSP/FT6336U/: ft6336u.c ft6336u.h MyI2C.c MyI2C.h
  group LVGL_porting
    ../LVGL/porting/: lv_port_indev.c lv_port_indev.h lv_port_disp.c lv_port_disp.h
  group LVGL_conf
    ../LVGL/: lv_conf.h lvgl.h
  group LVGL_src
    ../LVGL/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_observer.c lv_refr.c
    ../LVGL/src/debugging/monkey/: lv_monkey.c
    ../LVGL/src/debugging/profiler/: lv_profiler_builtin.c lv_profiler_builtin_posix.c
    ../LVGL/src/debugging/sysmon/: lv_sysmon.c
    ../LVGL/src/debugging/test/: lv_test_display.c lv_test_display_egl.c lv_test_fs.c lv_test_helpers.c lv_test_indev.c lv_test_indev_gesture.c lv_test_screenshot_compare.c
    ../LVGL/src/display/: lv_display.c
    ../LVGL/src/draw/convert/helium/: lv_draw_buf_convert_helium.c
    ../LVGL/src/draw/convert/: lv_draw_buf_convert.c
    ../LVGL/src/draw/convert/neon/: lv_draw_buf_convert_neon.c
    ../LVGL/src/draw/dma2d/: lv_draw_dma2d.c lv_draw_dma2d_fill.c lv_draw_dma2d_img.c
    ../LVGL/src/draw/espressif/ppa/: lv_draw_ppa.c lv_draw_ppa_buf.c lv_draw_ppa_fill.c lv_draw_ppa_img.c
    ../LVGL/src/draw/eve/: lv_draw_eve.c lv_draw_eve_arc.c lv_draw_eve_fill.c lv_draw_eve_image.c lv_draw_eve_letter.c lv_draw_eve_line.c lv_draw_eve_ram_g.c lv_draw_eve_triangle.c lv_eve.c
    ../LVGL/src/draw/: lv_draw.c lv_draw_3d.c lv_draw_arc.c lv_draw_blur.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_utils.c lv_draw_vector.c
    ../LVGL/src/draw/nanovg/: lv_draw_nanovg.c lv_draw_nanovg_3d.c lv_draw_nanovg_arc.c lv_draw_nanovg_blur.c lv_draw_nanovg_border.c lv_draw_nanovg_box_shadow.c lv_draw_nanovg_fill.c lv_draw_nanovg_grad.c lv_draw_nanovg_image.c lv_draw_nanovg_label.c lv_draw_nanovg_layer.c lv_draw_nanovg_line.c lv_draw_nanovg_mask_rect.c lv_draw_nanovg_triangle.c lv_draw_nanovg_vector.c lv_nanovg_fbo_cache.c lv_nanovg_image_cache.c lv_nanovg_utils.c
    ../LVGL/src/draw/nema_gfx/: lv_draw_nema_gfx.c lv_draw_nema_gfx_arc.c lv_draw_nema_gfx_border.c lv_draw_nema_gfx_cache.c lv_draw_nema_gfx_fill.c lv_draw_nema_gfx_img.c lv_draw_nema_gfx_label.c lv_draw_nema_gfx_layer.c lv_draw_nema_gfx_line.c lv_draw_nema_gfx_stm32_hal.c lv_draw_nema_gfx_triangle.c lv_draw_nema_gfx_utils.c lv_draw_nema_gfx_vector.c lv_nema_gfx_path.c
    ../LVGL/src/draw/nxp/g2d/: lv_draw_buf_g2d.c lv_draw_g2d.c lv_draw_g2d_fill.c lv_draw_g2d_img.c lv_g2d_buf_map.c lv_g2d_utils.c
    ../LVGL/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../LVGL/src/draw/opengles/: lv_draw_opengles.c
    ../LVGL/src/draw/renesas/dave2d/: lv_draw_dave2d.c lv_draw_dave2d_arc.c lv_draw_dave2d_border.c lv_draw_dave2d_fill.c lv_draw_dave2d_image.c lv_draw_dave2d_label.c lv_draw_dave2d_line.c lv_draw_dave2d_mask_rectangle.c lv_draw_dave2d_triangle.c lv_draw_dave2d_utils.c
    ../LVGL/src/draw/sdl/: lv_draw_sdl.c
    ../LVGL/src/draw/sifli/epic/: lv_draw_buf_sifli_epic.c lv_draw_sifli_epic.c lv_draw_sifli_epic_border.c lv_draw_sifli_epic_fill.c lv_draw_sifli_epic_img.c lv_draw_sifli_epic_label.c lv_draw_sifli_epic_layer.c lv_sifli_epic_cfg.c lv_sifli_epic_osa.c lv_sifli_epic_utils.c
    ../LVGL/src/draw/snapshot/: lv_snapshot.c
    ../LVGL/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_a8.c lv_draw_sw_blend_to_al88.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_argb8888_premultiplied.c lv_draw_sw_blend_to_i1.c lv_draw_sw_blend_to_l8.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_rgb565_swapped.c lv_draw_sw_blend_to_rgb888.c
    ../LVGL/src/draw/sw/blend/neon/: lv_draw_sw_blend_neon_to_rgb565.c lv_draw_sw_blend_neon_to_rgb888.c
    ../LVGL/src/draw/sw/blend/riscv_v/: lv_draw_sw_blend_riscv_v_to_rgb888.c
    ../LVGL/src/draw/sw/blend/sve2/: lv_draw_sw_blend_sve2_to_rgb888.c
    ../LVGL/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blur.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_grad.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../LVGL/src/draw/vg_lite/: lv_draw_buf_vg_lite.c lv_draw_vg_lite.c lv_draw_vg_lite_arc.c lv_draw_vg_lite_border.c lv_draw_vg_lite_box_shadow.c lv_draw_vg_lite_fill.c lv_draw_vg_lite_img.c lv_draw_vg_lite_label.c lv_draw_vg_lite_layer.c lv_draw_vg_lite_line.c lv_draw_vg_lite_mask_rect.c lv_draw_vg_lite_triangle.c lv_draw_vg_lite_vector.c lv_vg_lite_bitmap_font_cache.c lv_vg_lite_decoder.c lv_vg_lite_grad.c lv_vg_lite_math.c lv_vg_lite_path.c lv_vg_lite_pending.c lv_vg_lite_stroke.c lv_vg_lite_utils.c
    ../LVGL/src/drivers/display/drm/: lv_linux_drm.c lv_linux_drm_common.c lv_linux_drm_egl.c
    ../LVGL/src/drivers/display/fb/: lv_linux_fbdev.c
    ../LVGL/src/drivers/display/ft81x/: lv_ft81x.c
    ../LVGL/src/drivers/display/mipi/: lv_ili9341.c lv_lcd_generic_mipi.c lv_nv3007.c lv_st7735.c lv_st7789.c lv_st7796.c
    ../LVGL/src/drivers/display/nxp_elcdif/: lv_nxp_elcdif.c
    ../LVGL/src/drivers/display/renesas_glcdc/: lv_renesas_glcdc.c
    ../LVGL/src/drivers/display/st_ltdc/: lv_st_ltdc.c
    ../LVGL/src/drivers/draw/eve/: lv_draw_eve_display.c
    ../LVGL/src/drivers/evdev/: lv_evdev.c
    ../LVGL/src/drivers/libinput/: lv_libinput.c lv_xkb.c
    ../LVGL/src/drivers/nuttx/: lv_nuttx_cache.c lv_nuttx_entry.c lv_nuttx_fbdev.c lv_nuttx_image_cache.c lv_nuttx_lcd.c lv_nuttx_libuv.c lv_nuttx_mouse.c lv_nuttx_profiler.c lv_nuttx_touchscreen.c
    ../LVGL/src/drivers/opengles/assets/: lv_opengles_shader.c
    ../LVGL/src/drivers/opengles/glad/src/: egl.c gl.c gles2.c
    ../LVGL/src/drivers/opengles/: lv_opengles_debug.c lv_opengles_driver.c lv_opengles_egl.c lv_opengles_glfw.c lv_opengles_pbuffer.c lv_opengles_texture.c
    ../LVGL/src/drivers/opengles/opengl_shader/: lv_opengl_shader_manager.c lv_opengl_shader_program.c
    ../LVGL/src/drivers/qnx/: lv_qnx.c
    ../LVGL/src/drivers/sdl/: lv_sdl_egl.c lv_sdl_keyboard.c lv_sdl_mouse.c lv_sdl_mousewheel.c lv_sdl_sw.c lv_sdl_texture.c lv_sdl_window.c
    ../LVGL/src/drivers/uefi/: lv_uefi_context.c lv_uefi_display.c lv_uefi_indev_keyboard.c lv_uefi_indev_pointer.c lv_uefi_indev_touch.c lv_uefi_private.c
    ../LVGL/src/drivers/wayland/: lv_wayland.c lv_wayland_backend.c lv_wayland_backend_dmabuf.c lv_wayland_backend_egl.c lv_wayland_backend_g2d.c lv_wayland_backend_shm.c lv_wayland_dmabuf.c lv_wayland_keyboard.c lv_wayland_pointer.c lv_wayland_seat.c lv_wayland_touch.c lv_wayland_window.c lv_wayland_xdg_shell.c
    ../LVGL/src/drivers/windows/: lv_windows_context.c lv_windows_display.c lv_windows_input.c
    ../LVGL/src/drivers/x11/: lv_x11_display.c lv_x11_input.c
    ../LVGL/src/font/binfont_loader/: lv_binfont_loader.c
    ../LVGL/src/font/fmt_txt/: lv_font_fmt_txt.c
    ../LVGL/src/font/font_manager/: lv_font_manager.c lv_font_manager_recycle.c
    ../LVGL/src/font/freetype/: lv_freetype.c lv_freetype_glyph.c lv_freetype_image.c lv_freetype_outline.c lv_ftsystem.c
    ../LVGL/src/font/imgfont/: lv_imgfont.c
    ../LVGL/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_14.c lv_font_montserrat_14_aligned.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_source_han_sans_sc_14_cjk.c lv_font_source_han_sans_sc_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c
    ../LVGL/src/font/tiny_ttf/: lv_tiny_ttf.c
    ../LVGL/src/fs/: lv_fs.c lv_fs_fatfs.c lv_fs_frogfs.c lv_fs_littlefs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_uefi.c lv_fs_win32.c
    ../LVGL/src/image/: lv_bin_decoder.c lv_bmp.c lv_image_decoder.c lv_libjpeg_turbo.c lv_libpng.c lv_libwebp.c lv_lodepng.c lv_tjpgd.c
    ../LVGL/src/image/svg/: lv_svg.c lv_svg_decoder.c lv_svg_parser.c lv_svg_render.c lv_svg_token.c
    ../LVGL/src/indev/: lv_gridnav.c lv_indev.c lv_indev_gesture.c lv_indev_scroll.c
    ../LVGL/src/layouts/flex/: lv_flex.c
    ../LVGL/src/layouts/grid/: lv_grid.c
    ../LVGL/src/layouts/: lv_layout.c
    ../LVGL/src/libs/FT800-FT813/: EVE_commands.c EVE_supplemental.c
    ../LVGL/src/libs/barcode/: code128.c
    ../LVGL/src/libs/frogfs/src/: decomp_raw.c frogfs.c
    ../LVGL/src/libs/gif/: gif.c
    ../LVGL/src/libs/gltf/gltf_data/: lv_gltf_model_loader.c
    ../LVGL/src/libs/gltf/gltf_environment/: lv_gltf_ibl_sampler.c
    ../LVGL/src/libs/gltf/gltf_view/assets/: chromatic.c lv_gltf_view_shader.c
    ../LVGL/src/libs/gltf/math/: lv_3dmath.c
    ../LVGL/src/libs/lodepng/: lodepng.c
    ../LVGL/src/libs/lz4/: lz4.c
    ../LVGL/src/libs/nanovg/: nanovg.c
    ../LVGL/src/libs/qrcode/: qrcodegen.c
    ../LVGL/src/libs/rle/: lv_rle.c
    ../LVGL/src/libs/rlottie/: lv_rlottie.c
    ../LVGL/src/libs/tjpgd/: tjpgd.c
    ../LVGL/src/libs/vg_lite_driver/VGLiteKernel/: vg_lite_kernel.c
    ../LVGL/src/libs/vg_lite_driver/VGLite/: vg_lite.c vg_lite_image.c vg_lite_matrix.c vg_lite_path.c vg_lite_stroke.c
    ../LVGL/src/libs/vg_lite_driver/lv_vg_lite_hal/: lv_vg_lite_hal.c vg_lite_os.c
    ../LVGL/src/logging/: lv_log.c
    ../LVGL/src/: lv_conf_check.c lv_init.c
    ../LVGL/src/misc/cache/class/: lv_cache_lru_ll.c lv_cache_lru_rb.c lv_cache_sc_da.c
    ../LVGL/src/misc/cache/instance/: lv_image_cache.c lv_image_header_cache.c
    ../LVGL/src/misc/cache/: lv_cache.c lv_cache_entry.c
    ../LVGL/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_bidi_common.c lv_circle_buf.c lv_color.c lv_color_op.c lv_event.c lv_grad.c lv_iter.c lv_ll.c lv_lru.c lv_math.c lv_matrix.c lv_palette.c lv_pending.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_tree.c lv_utils.c
    ../LVGL/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_linux.c lv_mqx.c lv_os.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_sdl2.c lv_windows.c
    ../LVGL/src/others/file_explorer/: lv_file_explorer.c
    ../LVGL/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../LVGL/src/others/translation/: lv_translation.c
    ../LVGL/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
    ../LVGL/src/stdlib/clib/: lv_mem_core_clib.c lv_sprintf_clib.c lv_string_clib.c
    ../LVGL/src/stdlib/: lv_mem.c
    ../LVGL/src/stdlib/micropython/: lv_mem_core_micropython.c
    ../LVGL/src/stdlib/rtthread/: lv_mem_core_rtthread.c lv_sprintf_rtthread.c lv_string_rtthread.c
    ../LVGL/src/stdlib/uefi/: lv_mem_core_uefi.c
    ../LVGL/src/themes/default/: lv_theme_default.c
    ../LVGL/src/themes/: lv_theme.c
    ../LVGL/src/themes/mono/: lv_theme_mono.c
    ../LVGL/src/themes/simple/: lv_theme_simple.c
    ../LVGL/src/tick/: lv_tick.c
    ../LVGL/src/widgets/3dtexture/: lv_3dtexture.c
    ../LVGL/src/widgets/animimage/: lv_animimage.c
    ../LVGL/src/widgets/arc/: lv_arc.c
    ../LVGL/src/widgets/arclabel/: lv_arclabel.c
    ../LVGL/src/widgets/bar/: lv_bar.c
    ../LVGL/src/widgets/barcode/: lv_barcode.c
    ../LVGL/src/widgets/button/: lv_button.c
    ../LVGL/src/widgets/buttonmatrix/: lv_buttonmatrix.c
    ../LVGL/src/widgets/calendar/: lv_calendar.c lv_calendar_chinese.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../LVGL/src/widgets/canvas/: lv_canvas.c
    ../LVGL/src/widgets/chart/: lv_chart.c
    ../LVGL/src/widgets/checkbox/: lv_checkbox.c
    ../LVGL/src/widgets/dropdown/: lv_dropdown.c
    ../LVGL/src/widgets/ffmpeg/: lv_ffmpeg.c
    ../LVGL/src/widgets/gif/: lv_gif.c
    ../LVGL/src/widgets/gstreamer/: lv_gstreamer.c
    ../LVGL/src/widgets/image/: lv_image.c
    ../LVGL/src/widgets/imagebutton/: lv_imagebutton.c
    ../LVGL/src/widgets/ime/: lv_ime_pinyin.c
    ../LVGL/src/widgets/keyboard/: lv_keyboard.c
    ../LVGL/src/widgets/label/: lv_label.c
    ../LVGL/src/widgets/led/: lv_led.c
    ../LVGL/src/widgets/line/: lv_line.c
    ../LVGL/src/widgets/list/: lv_list.c
    ../LVGL/src/widgets/lottie/: lv_lottie.c
    ../LVGL/src/widgets/menu/: lv_menu.c
    ../LVGL/src/widgets/msgbox/: lv_msgbox.c
    ../LVGL/src/widgets/objx_templ/: lv_objx_templ.c
    ../LVGL/src/widgets/property/: lv_animimage_properties.c lv_arc_properties.c lv_bar_properties.c lv_buttonmatrix_properties.c lv_chart_properties.c lv_checkbox_properties.c lv_dropdown_properties.c lv_image_properties.c lv_keyboard_properties.c lv_label_properties.c lv_led_properties.c lv_line_properties.c lv_menu_properties.c lv_obj_properties.c lv_roller_properties.c lv_scale_properties.c lv_slider_properties.c lv_span_properties.c lv_spinbox_properties.c lv_spinner_properties.c lv_style_properties.c lv_switch_properties.c lv_table_properties.c lv_tabview_properties.c lv_textarea_properties.c
    ../LVGL/src/widgets/qrcode/: lv_qrcode.c
    ../LVGL/src/widgets/roller/: lv_roller.c
    ../LVGL/src/widgets/scale/: lv_scale.c
    ../LVGL/src/widgets/slider/: lv_slider.c
    ../LVGL/src/widgets/span/: lv_span.c
    ../LVGL/src/widgets/spinbox/: lv_spinbox.c
    ../LVGL/src/widgets/spinner/: lv_spinner.c
    ../LVGL/src/widgets/switch/: lv_switch.c
    ../LVGL/src/widgets/table/: lv_table.c
    ../LVGL/src/widgets/tabview/: lv_tabview.c
    ../LVGL/src/widgets/textarea/: lv_textarea.c
    ../LVGL/src/widgets/tileview/: lv_tileview.c
    ../LVGL/src/widgets/win/: lv_win.c
  group freertos/inc
    ../freertos/inc/: FreeRTOSConfig.h atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/port
    ../freertos/port/: heap_4.c port.c portmacro.h portasm.c portasm.h portmacrocommon.h
  group freertos/src
    ../freertos/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32u5xx.c
  group Drivers/STM32U5xx_HAL_Driver
    ../Drivers/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_tim.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_cortex.c stm32u5xx_hal_dma2d.c stm32u5xx_hal.c stm32u5xx_hal_i2c.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_rcc.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_flash.c stm32u5xx_hal_flash_ex.c stm32u5xx_hal_gpio.c stm32u5xx_hal_dma.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c stm32u5xx_hal_pwr.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_gtzc.c stm32u5xx_hal_icache.c stm32u5xx_hal_spi.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_uart.c stm32u5xx_hal_uart_ex.c
software components: CMSIS:CORE 5.6.0
